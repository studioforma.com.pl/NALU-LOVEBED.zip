Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Nalu-Lovebed - ver4.ifc
Time: 2024-10-24T10:49:21
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (4)
Name
 | Nalu-Lovebed_0 - ObjectType: SketchupGroup
 | Nalu-Lovebed_1 - ObjectType: SketchupGroup
 | Nalu-Lovebed_2 - ObjectType: SketchupGroup
 | Nalu-Lovebed_3 - ObjectType: SketchupGroup
